<?xml version="1.0" encoding="utf-8"?>
<workspace>
  <projects>
    <project path="STM32F405_Project.ewp"/>
  </projects>
</workspace>
