# IAR project kp7.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-ec-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: E:\sim800Elam2560_bootnew_i2cerr\lnkm2560s.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: Appl_sec.c at_com.h at_com4.c base1.c boot_f_ar2.s90 bpa.c bpa.h coder.c control_tc.c errata.s90 fppp3.c fram1.c interr4.c JMP_BOOT.s90 kd.c ldterm1.c ledmd.c local.c logs.c main.c pins.c R_flash.s90 spvisor.c tc_avtom.h tchmem.c util_stk.s90
